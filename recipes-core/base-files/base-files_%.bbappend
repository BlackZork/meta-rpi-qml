# Use DHCP server to assign hostname
hostname=""