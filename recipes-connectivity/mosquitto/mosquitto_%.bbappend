BBCLASSEXTEND = "nativesdk"