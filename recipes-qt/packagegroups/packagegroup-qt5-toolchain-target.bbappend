RDEPENDS_${PN} += " \
    mosquitto-dev \
"