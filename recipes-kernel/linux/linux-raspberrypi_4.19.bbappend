LINUX_VERSION = "4.19.75"

#SRCREV = "4d486c17f636bb339c10cd73a07292220a973e01"
SRCREV = "642e12d892e694214e387208ebd9feb4a654d287"